RPROVIDES:${PN} += "virtual-opencl-icd"