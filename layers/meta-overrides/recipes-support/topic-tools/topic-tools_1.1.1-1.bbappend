# see meta-ros2-humble patch
ERROR_QA:remove = "patch-status"