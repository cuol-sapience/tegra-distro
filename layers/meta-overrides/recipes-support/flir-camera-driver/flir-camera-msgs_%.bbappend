# upstream is just "Apache"
LICENSE = "Apache-2.0"