include spinnaker-sdk.inc

PV = "4.2.0.88"
PR = "r0"


SPINNAKER_OS_VERSION ?= "22.04"

SPINNAKER_SHA256:x86_64 = "c11205b1c2d0974b9396c178163702e4f92ed55bdf7d66770d55fb3f214aa0cb"
SPINNAKER_SHA256:aarch64 = "d8ad748ac4f2511243db2e932583388b5fa7458cf62169666f76c03029d41d71"
SPINNAKER_SHA256:arm = "d7aa1188a2d76c4636bb5e7603539081d8626927408552f98545e86b43f423be"