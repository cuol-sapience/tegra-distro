EXTRA_OECMAKE += "\
    -DSPDLOG_FMT_EXTERNAL=ON \
"