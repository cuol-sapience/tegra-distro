LICENSE = "BSD-3-Clause"

inherit cuda
DEPENDS:append:jetson-orin-nano-devkit = " cuda-toolkit"