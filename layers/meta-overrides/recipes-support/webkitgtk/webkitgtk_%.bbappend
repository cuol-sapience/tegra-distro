DEPENDS:append = " egl-gbm"

# https://lists.openembedded.org/g/openembedded-core/topic/patch_2_2_webkitgtk/116823456
DEBUG_LEVELFLAG = "-g1"