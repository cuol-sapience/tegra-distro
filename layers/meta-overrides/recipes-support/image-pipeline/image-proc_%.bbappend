inherit cuda-available