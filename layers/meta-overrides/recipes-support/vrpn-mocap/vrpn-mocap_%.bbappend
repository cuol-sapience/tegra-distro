EXTRA_OECMAKE += "-DCMAKE_HAVE_THREADS_LIBRARY=1"