NON_WHINLATTER_S = "${WORKDIR}/sources/${BPN}-${PV}"
