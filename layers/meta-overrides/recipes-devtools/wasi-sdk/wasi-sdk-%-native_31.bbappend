NON_WHINLATTER_S = "${WORKDIR}/sources/${BPN}-${PV}"

do_compile[network] = "1"