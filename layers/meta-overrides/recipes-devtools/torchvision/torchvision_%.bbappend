RPROVIDES:torchvision += "python3-torchvision"
DEPENDS:append:cuda = " cuda-compatibility-workarounds"
