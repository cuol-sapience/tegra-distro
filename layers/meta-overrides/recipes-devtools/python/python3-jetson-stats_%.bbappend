FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0003-fix-multiprocessing-on-python-3-14.patch \
           "