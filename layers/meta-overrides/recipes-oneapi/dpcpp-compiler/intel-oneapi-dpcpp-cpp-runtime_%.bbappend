RPROVIDES:${PN} += "\
    libiomp5.so(VERSION)(64bit) \
    libiomp5.so()(64bit)
"