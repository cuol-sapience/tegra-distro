DEPENDS:append = " libxxf86vm"