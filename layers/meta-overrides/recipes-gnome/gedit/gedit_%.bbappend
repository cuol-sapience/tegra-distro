# tries to clone GNOME libgd at configure time 05/04/26
do_configure[network] = "1"