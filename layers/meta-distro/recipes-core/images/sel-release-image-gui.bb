require sel-edge-image-gui.bb

SUMMARY = "SEL release image (with desktop)"

PACKAGE_FEED_BASE_PATHS:remove = "edge"
