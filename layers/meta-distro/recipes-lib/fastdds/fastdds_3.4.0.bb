require ${PN}.inc
SRCREV = "50f14ab37b41eb9864fd6908b24e3a3967f79952"
SRC_URI = "git://github.com/eProsima/Fast-DDS;branch=release/3.4.0;name=release/3.4.0;protocol=https"