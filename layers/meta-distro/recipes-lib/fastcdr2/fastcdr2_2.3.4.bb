require ${PN}.inc
SRCREV = "dd535f7b5fe4bc5ff95a2e57e041317ba0a7027d"
SRC_URI = "git://github.com/eProsima/Fast-CDR.git;branch=2.3.4;name=2.3.4;protocol=https"