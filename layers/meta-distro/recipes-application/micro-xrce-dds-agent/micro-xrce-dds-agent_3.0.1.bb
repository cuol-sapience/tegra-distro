require ${PN}.inc
SRCREV = "155cfaaf8b7abac2e85d4a62d3649b09ace0be55"
SRC_URI = "git://github.com/eProsima/Micro-XRCE-DDS-Agent.git;branch=master;name=master;protocol=https"